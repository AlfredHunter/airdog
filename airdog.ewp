# IAR project airdog.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 1
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: FWlib\inc; FWLIB\src; USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: airdog.bin
  ILINK.IlinkOutputFile: airdog.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group FWLIB
    FWlib/src/: stm8s_adc1.c stm8s_beep.c stm8s_clk.c stm8s_gpio.c stm8s_iwdg.c stm8s_rst.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c stm8s_wwdg.c
  group USER
    USER/: adc.c alarm_judge.c beep.c iwdg.c led.c main.c stm8s_conf.h stm8s_interruput.c tim1.c uart.c wwdg.c
